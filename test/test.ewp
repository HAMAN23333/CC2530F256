# IAR project test.ewp, settings and files
configuration Debug (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2530F256.i51
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\CC2530_lib\basicrf; ..\CC2530_lib\board; ..\CC2530_lib\common; ..\CC2530_lib\utils; sensor
  ICC8051.CCOptLevel: 1
  ICC8051.CCOptStrategy: 0
  ICC8051.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_cc2530F256_banked.xcl
configuration Release (8051)
  as the first configuration, except:
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\
  General.RTConfigPath: xxx.h
  ICC8051.CCDefines: NDEBUG
  ICC8051.CCOptLevel: 3
  A8051.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
configuration Major (8051, debug)
  as the first configuration, except:
configuration Remote (8051, debug)
  as the first configuration, except:
configuration test (8051, debug)
  as the first configuration, except:
  group app
    Major/: Major.c
    Remote/: Remote.c
    test/: test.c
  group basicrf
    ../CC2530_lib/basicrf/: basic_rf.c basic_rf.h basic_rf_security.c basic_rf_security.h
  group board
    ../CC2530_lib/board/: hal_board.c hal_board.h hal_led.c hal_led.h
  group common
    ../CC2530_lib/common/: hal_adc.c hal_adc.h hal_cc8051.h hal_clock.c hal_clock.h hal_defs.h hal_digio.c hal_digio.h hal_int.c hal_int.h hal_mcu.c hal_mcu.h hal_rf.c hal_rf.h hal_rf_security.c hal_rf_security.h hal_rf_util.c hal_rf_util.h hal_sleep.c hal_sleep.h hal_timer_32k.c hal_timer_32k.h hal_uart.c hal_uart.h hal_uart1.c hal_uart1.h TIMER.c TIMER.h
  group sensor
    sensor/: sensor.c sensor.h
  group utils
    ../CC2530_lib/utils/: util.c util.h
